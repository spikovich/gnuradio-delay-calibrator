options:
  parameters:
    generate_options: qt_gui
    id: sa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: compensation_delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: reset_calibration_button
  id: variable_qtgui_push_button
  parameters:
    label: Reset Calibration
    pressed: '1'
    released: '0'
    type: bool
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: start_calibration_button
  id: variable_qtgui_push_button
  parameters:
    label: Start Calibration
    pressed: '1'
    released: '0'
    type: bool
    value: 'False'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '5'
    showports: 'True'
    type: byte
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: compensation_delay
    showports: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt 

      class blk(gr.sync_block):
          """
          Embedded Python Block to detect delay between two signals using cross-correlation
          and publish the result as a PMT message.
          """

          def __init__(self, buffer_size=1024):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Delay Correaltion EPB',
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              self.buffer_size = int(buffer_size)
              self.message_port_register_out(pmt.intern('delay_lag'))

              self.buf0 = np.zeros(self.buffer_size, dtype=np.float32)
              self.buf1 = np.zeros(self.buffer_size, dtype=np.float32)
              self.ptr = 0
              self.correlation_done = False
              self.calibration_active = False

              self.tb = None

          def start_calibration(self):
              """Called to start the calibration process."""
              print("EPB: Start Calibration Requested")
              self.ptr = 0
              self.correlation_done = False
              self.calibration_active = True

          def reset_calibration(self):
              """Called to reset the calibration."""
              print("EPB: Reset Calibration Requested")
              self.calibration_active = False
              self.correlation_done = True

          def work(self, input_items, output_items):
              data0 = input_items[0]
              data1 = input_items[1]
              num_samples_to_process = len(data0)

              if self.calibration_active and not self.correlation_done:
                  samples_to_copy = min(num_samples_to_process, self.buffer_size - self.ptr)

                  if samples_to_copy > 0:
                      self.buf0[self.ptr : self.ptr + samples_to_copy] = data0[:samples_to_copy]
                      self.buf1[self.ptr : self.ptr + samples_to_copy] = data1[:samples_to_copy]
                      self.ptr += samples_to_copy

                  if self.ptr >= self.buffer_size:
                      print(f"EPB: Buffer full ({self.ptr} samples). Performing correlation...")
                      x0 = self.buf0 - np.mean(self.buf0)
                      x1 = self.buf1 - np.mean(self.buf1)
                      corr = np.correlate(x0, x1, mode='full')
                      lag = int(np.argmax(corr) - (self.buffer_size - 1))
                      print(f"EPB: Correlation complete. Calculated Lag = {lag}")
                      self.message_port_pub(pmt.intern('delay_lag'), pmt.to_pmt(lag))
                      self.correlation_done = True
                      self.calibration_active = False
                      print("EPB: Lag message published. Calibration cycle finished.")

              output_items[0][:num_samples_to_process] = 0.0

              return num_samples_to_process
    buffer_size: '1024'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    size: '200'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_delay_0, '0']
- [analog_random_source_x_0, '0', blocks_delay_1, '0']
- [blocks_char_to_float_0, '0', epy_block_0, '0']
- [blocks_char_to_float_1, '0', epy_block_0, '1']
- [blocks_delay_0, '0', blocks_char_to_float_0, '0']
- [blocks_delay_1, '0', blocks_char_to_float_1, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, delay_lag, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
